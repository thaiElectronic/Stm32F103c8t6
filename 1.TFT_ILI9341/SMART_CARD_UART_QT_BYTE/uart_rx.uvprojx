# Keil uVision project uart_rx.uvprojx, settings and files
target uart_rx (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: blinkled +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\project;.\lib\CMSIS\CM3\CoreSupport;.\lib\STM32F10x_StdPeriph_Driver\inc;.\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;.\usart_per\gpio;.\LIB_LAB\include\irc;.\LIB_LAB\include\src;..\1.Test_Lib;..\1.1.Test_button
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ./lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ./lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_tim.c stm32f10x_adc.c
  group user
    ./project/: main.c stm32f10x_it.c system_stm32f10x.c
  group lib_user
    ./LIB_LAB/include/src/: mcu-gpio.c mcu-usart.c mcu-tim.c mcu-delay.c mcu-adc.c
software components: CMSIS:CORE 5.4.0
