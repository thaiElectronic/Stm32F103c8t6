# Keil uVision project Smart_Card.uvprojx, settings and files
target Smart_Card (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Smart_Card
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\LIB;..\LIB\Lib_Json;..\LIB\Lib_User;..\USER;..\LIB\Lib_TFT;..\LIB\Lib_TFT\USER;..\LIB\Lib_TFT\SYSTEM\delay;..\LIB\Lib_TFT\SYSTEM\sys;..\LIB\Lib_TFT\HARDWARE;..\LIB\Lib_SD_Card;..\LIB\Lib_FATFS_V0.09\src;..\LIB\Lib_RFID
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../USER/: main.c system.c
  group Smart_Card_driver
    ../LIB/Lib_Json/: Smart_lock_Json.c
    ../LIB/Lib_TFT/: Smart_lock_TFT.c
    ../LIB/Lib_SD_Card/: Smart_lock_SD_Card.c
    ../LIB/Lib_RFID/: Smart_lock_RFID.c
  group Lib_LCD
    ../LIB/Lib_TFT/USER/: GUI.c test.c
    ../LIB/Lib_TFT/SYSTEM/delay/: delay.c
    ../LIB/Lib_TFT/SYSTEM/sys/: sys.c
    ../LIB/Lib_TFT/HARDWARE/: led.c lcd.c
  group Lib_RFID
    ../LIB/Lib_RFID/: mcu-mfrc522.c
  group Lib_SD_Card
    ../LIB/Lib_SD_Card/: SPI_MSD0_Driver.c SPI_MSD1_Driver.c
    ../LIB/Lib_FATFS_V0.09/src/: ccsbcs.c diskio.c ff.c
  group Lib_User
    ../LIB/Lib_User/: mcu-gpio.c SPI.c Timer.c UART.c
software components: CMSIS:CORE 5.4.0, Data Exchange:JSON:Jansson 2.7.0, Device:DMA 1.2, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:WWDG 3.5.0
