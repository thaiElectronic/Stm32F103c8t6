# Keil uVision project Smart_Home.uvprojx, settings and files
target Smart_home (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: blinkled_pwm +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\project;.\lib\CMSIS\CM3\CoreSupport;.\lib\STM32F10x_StdPeriph_Driver\inc;.\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;.\user lib\irc;.\user lib\src;.\project
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ./lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ./lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_spi.c
  group user
    ./project/: main.c stm32f10x_it.c system_stm32f10x.c
  group user LIB
    ./user lib/src/: mcu-gpio.c mcu-tim.c mcu-usart.c mcu-spi.c mcu-lcd.c mcu-mfrc522.c mcu-adc.c mcu-dht11.c mcu-delay.c
